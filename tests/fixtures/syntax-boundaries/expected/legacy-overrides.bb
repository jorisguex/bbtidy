FILES_${PN} = "/usr/bin/example"
RDEPENDS_${PN} += "python3"
SRC_URI = "git://example.invalid/example.git;branch=main"
