SRC_URI = "file://one.patch \
    file://two.patch
