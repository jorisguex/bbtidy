SUMMARY="Malformed function"
do_install() {
    install -d ${D}${bindir}
