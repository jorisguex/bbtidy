do_install() {
    cat <<'EOF'
}
