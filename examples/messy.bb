VAR = "val"
VAR2  =  "val2"

VAR3 = "val3"
